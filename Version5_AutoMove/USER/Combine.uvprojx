# Keil uVision project Combine.uvprojx, settings and files
target Combine (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Combine +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\FWLIB\inc;..\HARDWARE\24CXX;..\HARDWARE\FLASH;..\HARDWARE\IIC;..\HARDWARE\KEY;..\HARDWARE\PWM;..\HARDWARE\TIMER;..\HARDWARE\TOUCH;..\BSP\bsp;..\BSP\modbus;..\BSP\timer;..\TASK\CM_Control;..\TASK\Base_Calculation;..\BSP\encoder;..\TASK\Encoder_Read;..\BSP\usart;..\HARDWARE\VISUAL_SCOPE;..\TASK\Propeller_Control;..\TASK\Step_Motor_Control;..\BSP\exti;..\TASK\Remote_Decode;..\TASK\Roller_Control;..\TASK\Imu_Decode;..\HARDWARE\OLED;..\TASK\Capture;..\TASK\Putter_Control;..\TASK\Ultrasonic_Control
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/VISUAL_SCOPE/: visual_scope.c
    ../HARDWARE/OLED/: oled.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_exti.c stm32f4xx_dac.c stm32f4xx_dma.c
  group BSP
    ../BSP/bsp/: bsp.c
    ../BSP/modbus/: modbus.c
    ../BSP/timer/: timer.c
    ../BSP/encoder/: encoder.c
    ../BSP/usart/: usart.c
    ../BSP/exti/: exti.c
  group TASK
    ../TASK/Base_Calculation/: Base_Calculation.c
    ../TASK/CM_Control/: CM_Control.c
    ../TASK/Encoder_Read/: encoder_read.c
    ../TASK/Propeller_Control/: Propeller_Control.c
    ../TASK/Step_Motor_Control/: Step_Motor_Control.c
    ../TASK/Remote_Decode/: remote_decode.c
    ../TASK/Roller_Control/: Roller_Control.c
    ../TASK/Imu_Decode/: Imu_Decode.c
    ../TASK/Capture/: capture.c
    ../TASK/Putter_Control/: Putter_Control.c
    ../TASK/Ultrasonic_Control/: Ultrasonic.c
